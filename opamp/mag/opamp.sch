v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {nmos.sym} -50 -50 0 0 {name=x1}
C {nmosout.sym} -70 -130 0 0 {name=x2}
C {pmoscs.sym} -50 180 0 0 {name=x3}
C {pmosout.sym} -40 70 0 0 {name=x4}
C {devices/lab_pin.sym} 100 150 2 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 100 170 2 0 {name=p2 sig_type=std_logic lab=n1}
C {devices/lab_pin.sym} 100 190 2 0 {name=p3 sig_type=std_logic lab=n2}
C {devices/lab_pin.sym} 100 210 2 0 {name=p4 sig_type=std_logic lab=n3}
C {devices/lab_pin.sym} -200 -40 0 0 {name=p5 sig_type=std_logic lab=n1
}
C {devices/lab_pin.sym} -200 -60 0 0 {name=p6 sig_type=std_logic lab=n2
}
C {devices/lab_pin.sym} -190 50 0 0 {name=p7 sig_type=std_logic lab=n3
}
C {devices/lab_pin.sym} -190 70 0 0 {name=p8 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} -190 90 0 0 {name=p9 sig_type=std_logic lab=VIP
}
C {devices/lab_pin.sym} 100 -60 2 0 {name=p10 sig_type=std_logic lab=RS}
C {devices/lab_pin.sym} 100 -40 2 0 {name=p11 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 110 50 2 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 110 70 2 0 {name=p13 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 110 90 2 0 {name=p14 sig_type=std_logic lab=n4}
C {devices/lab_pin.sym} 80 -150 2 0 {name=p15 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 80 -130 2 0 {name=p16 sig_type=std_logic lab=n4}
C {devices/lab_pin.sym} 80 -110 2 0 {name=p17 sig_type=std_logic lab=GND}
